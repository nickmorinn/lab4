# Keil uVision project Blynk.uvprojx, settings and files
target Blynk (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blynk
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s PLL.c UART.c Blynk.c ST7735.c Timer2.c Timer3.c esp8266.c PortF.c
    C:/Users/jmars/Downloads/lab4-master/lab4-master/Lab4/: ADCSWTrigger.c Button.c Buttons.c Lab3.c LCD.c PWM.c Speaker.c Switch.c Systick.c Timers.c ADCSWTrigger.h Button.h Buttons.h Lab3.h LCD.h PLL.h PortF.h PWM.h Speaker.h Switch.h Systick.h Timers.h
software components: CMSIS:CORE 5.0.2
