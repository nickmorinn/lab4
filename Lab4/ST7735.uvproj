# Keil uVision project ST7735.uvproj, settings and files
target ST7735 (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: ST7735
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s PLL.c ST7735.c Lab3.c Timers.c Speaker.c Systick.c LCD.c ADCSWTrigger.c ADCSWTrigger.h Buttons.c PWM.c Blynk.c esp8266.c Timer2.c Timer3.c UART.c esp8266.h Timer2.h Timer3.h UART.h
